# Keil uVision project USER.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: USER +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HARDWARE\wheel;.\HARDWARE\Delay;.\HARDWARE\run;.\HARDWARE\sonar;.\HARDWARE\fan;.\HARDWARE\fire;.\HARDWARE\fire;.\HARDWARE\sonar2
  group USER
    ./: main.c
  group HARDWARE
    ./HARDWARE/wheel/: wheel.c wheel.h
    ./HARDWARE/run/: run.c run.h
    ./HARDWARE/Delay/: Delay.c Delay.h
    ./HARDWARE/sonar/: sonar.h sonar.c
    ./HARDWARE/fan/: fan.c fan.h
    ./HARDWARE/fire/: fire.c fire.h
    ./HARDWARE/sonar2/: sonar2.c sonar2.h
